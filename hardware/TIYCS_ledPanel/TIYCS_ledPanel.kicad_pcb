File: hardware/TIYCS_ledPanel/TIYCS_ledPanel.kicad_pcb (KiCad board)
At the start: 2 copper layers, 203 x 203 mm, 450 parts

Commit message: Bugfixes?
Routing:
- net W: track 1941.7 -> 1947.5 mm
